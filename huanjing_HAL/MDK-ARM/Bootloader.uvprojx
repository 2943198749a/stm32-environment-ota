# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;..\..\portable_ota\stm32;..\..\portable_ota\stm32\ota_core\Inc
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f103xe.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group OTA/Bootloader
    ../../portable_ota/stm32/stm32f103_example/bootloader/: boot_main.c
    ../../portable_ota/stm32/ota_core/Src/: ota_storage.c ota_metadata.c ota_integrity.c sha256.c
software components: CMSIS:CORE 5.6.0
